# Repository xywatch/watchy-hardware-v2

File README.md:

# watchy-hardware-v2
This project involves modifying the <a href="https://github.com/sqfmi/watchy-hardware">Watchy Hardware V2</a> by replacing the Micro USB port with a Type-C interface. There are two versions available for the serial chip:

* CP2102N version
* CH340X version

We recommend using the CH340X version because:

* It's cheaper
* Has a smaller package size
* Easier to solder
* Requires fewer external components

## CP2102N

## CH340X

## 中文

本项目是修改了watchy hardware v2将micro usb改成了typec接口, 针对串口芯片有两个版本:
* CP2102N
* CH340X
推荐使用 CH340X 版本, 因为CH340X便宜, 封装小, 易焊接, 外围电路少.

## KiCad design v2.0-typec-CP2102N/Watchy.kicad_pcb

Parts:
AE1: SWRA117D
C1, C14: 100nF; C_0603_1608Metric
C2, C5, C6, C7, C8, C9, C10: 1uF/50V; C_0603_1608Metric
C3, C4, C12: 4.7uF/50V; C_0805
C11, C13: 4.7uF; C_0402_1005Metric
D1, D2, D3, D4: MBR0530; D_SOD-123F
D5: LED; LED_0603
D6: 1N4001; D_SOD-123F
GND2: GND; TestPoint_Pad_D1.0mm
GPIO0: GPIO0; TestPoint_Pad_D1.0mm
J1: FPC24(0.5MM); 24_Pins_0.5mm_Pitch_ZIF_Connector_UP
J2: Conn_01x04; PinHeader_1x04_P1.27mm_Vertical
J3: Battery; 1.25T-2PWT (Molex 532610271)
L1: 10uH 1A; Inductors_Inductor_Taiyo-Yuden_NR-40xx
M1: Vibration_Motor; Motor_Header
Q1: AO3400A; SOT-23
Q2: UMH3N; SOT-363_SC-70-6
Q4: CJ2301; SOT-23
Q5: S8050; SOT-23
R1, R4, R5, R6, R7, R8, R10, R14, R15: 10K; R0402-Frame
R2, R3: 4.7K; R0402-Frame
R9: 3; R0402-Frame
R11: 680K; R0402-Frame
R12, R13, R19, R20: 100K; R0402-Frame
R16, R17: 1K; R0402-Frame
R18: 220K; R0402-Frame
SW1, SW2, SW3, SW4: BTN; K2-1114SA-A4SW-06
TYPEC1: USB_C_Receptacle_USB2.0_14P; USB_C_Receptacle_HRO_TYPE-C-31-M-12
U1: ESP32-PICO-D4; QFN-48-1EP_7x7mm_Pitch0.5mm
U2: ME6211C33M5G-N; SOT-23-5
U3: CP2102; QFN-24-1EP_4x4mm_Pitch0.5mm
U4: BMA423; LGA-12_2x2mm_Pitch0.5mm
U5: TP4054; SOT-23-5
U6: PCF8563BS; DFN-10-1EP_3x3mm_P0.5mm_EP1.7x2.5mm
Y1: 32.768KHz; Crystal_SMD_3215-2Pin_3.2x1.5mm

Connections:
32KHZ: R19.2, U1.13 (IO33), U6.8 (CLKO)
+3V3: C4.1, C7.1, C12.1, C14.1, D6.1 (K), J1.15, J1.16, J2.2, L1.2, M1.1 (+), R1.1, R2.1, R3.1, R20.1, SW1.1, SW2.1, SW3.1, SW4.1, U1.1 (VDDA), U1.3 (VDDA3P3), U1.4 (VDDA3P3), U1.19 (VDD3P3_RTC), U1.37 (VDD3P3_CPU), U1.43 (VDDA), U1.46 (VDDA), U2.5 (OUT), U4.3 (VDDIO), U4.7 (VDD), U4.10 (CSB)
+BATT: J3.1, Q4.3 (D), R7.1, R11.1, R12.1, U5.3 (VBAT), U6.9 (VDD)
ACC_INT_1: U1.17 (IO14), U4.5 (INT1)
ACC_INT_2: U1.18 (IO12), U4.6 (INT2)
ADC: R12.2, R13.1, U1.10 (IO34)
BTN_1: R4.2, SW1.2, U1.15 (IO26)
BTN_2: R5.2, SW2.2, U1.14 (IO25)
BTN_3: R6.2, SW3.2, U1.11 (IO35)
BTN_4: R10.2, SW4.2, U1.24 (IO4)
BUSY: J1.9, U1.38 (IO19)
DC: J1.11, U1.29 (SD3/IO10)
DTR: Q2.2 (B1), Q2.4 (E2), U3.23 (DTR)
EN: C1.1, Q2.6 (C1), R1.2, U1.9 (EN)
GDR: J1.2, Q1.1 (G), R8.1
GND: AE1.2 (PCB_Trace), C1.2, C2.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.1, C12.2, C13.2, D2.1 (K), GND2.1, J1.8, J1.17, J2.1, J3.2, Q5.2 (E), R4.1, R5.1, R6.1, R8.2, R9.1, R10.1, R13.2, R14.2, R15.1, R18.2, TYPEC1.A1 (GND), TYPEC1.A12 (GND), TYPEC1.B1 (GND), TYPEC1.B12 (GND), U1.21 (IO15), U1.49 (GND), U2.2 (GND), U3.2 (GND), U4.1 (SDO), U4.8 (GNDIO), U4.9 (GND), U5.2 (VSS), U6.5 (VSS)
GPIO0: GPIO0.1, Q2.3 (C2), U1.23 (IO0)
MOSI: J1.14, U1.36 (IO23)
unnamed: AE1.1 (FEED), U1.2 (LNA_IN)
unnamed: C3.1, D1.1 (K), D2.2 (A)
unnamed: C3.2, D3.2 (A), L1.1, Q1.3 (D)
unnamed: D4.1 (K), Q4.2 (S), U2.1 (IN), U2.3 (EN)
unnamed: D5.1 (K), R16.1
unnamed: C14.2, D6.2 (A), M1.2 (-), Q5.3 (C)
unnamed: C2.1, J1.5
unnamed: C6.1, J1.18
unnamed: C8.1, J1.20
unnamed: C9.1, J1.22
unnamed: C10.1, J1.24
unnamed: Q5.1 (B), R17.1
unnamed: R11.2, R18.1, R19.1
unnamed: TYPEC1.A6 (D+), TYPEC1.B6 (D+), U3.3 (D+)
unnamed: TYPEC1.A7 (D-), TYPEC1.B7 (D-), U3.4 (D-)
unnamed: C13.1, U3.5 (VIO), U3.6 (VDD)
unnamed: R15.2, U5.5 (PROG)
unnamed: R16.2, U5.1 (STAT)
unnamed: U6.1 (OSCI), Y1.1
unnamed: U6.2 (OSCO), Y1.2
PREVGH: C5.1, D3.1 (K), J1.21
PREVGL: D1.2 (A), J1.23
RES: J1.10, R20.2, U1.28 (SD2/IO9)
RESE: J1.3, Q1.2 (S), R9.2
RTC_INT: R7.2, U1.16 (IO27), U6.4 (~INT)
RTS: Q2.1 (E1), Q2.5 (B2), U3.19 (RTS)
RX: U1.40 (U0RXD/IO3), U3.21 (TXD)
SCK: J1.13, U1.35 (IO18)
SCL: J2.3, R2.2, U1.39 (IO22), U4.12 (SCX), U6.7 (SCL)
SDA: J2.4, R3.2, U1.42 (IO21), U4.2 (SDX), U6.6 (SDA)
SS: J1.12, U1.34 (IO5)
TX: U1.41 (U0TXD/IO1), U3.20 (RXD)
VBUS: C11.2, D4.2 (A), D5.2 (A), Q4.1 (G), R14.1, TYPEC1.A4 (VBUS), TYPEC1.A9 (VBUS), TYPEC1.B4 (VBUS), TYPEC1.B9 (VBUS), U3.7 (REGIN), U3.8 (VBUS), U5.4 (VDD)
VIB_PWM: R17.2, U1.20 (IO13)

Notes on the sheet:
Real Time Clock
ESP32-PICO-D4
Vibration Motor
1=charging 当没有电池时, VBUS 5v变成VBAT VBAT: 4.2v 此时时钟有问题, 可能是换了TP4057导致 当没有电池时, VBAT: 3.75v
E-Paper Driver
Power & Battery
USB-Serial
Q2=Q2A+A2B, 6个引角
Buttons
Accelerometer

Board: 2 copper layers, 33.8 x 46.0 mm, 64 parts (0 on the bottom side), 52 nets.

## Commit log

2025-04-10 init
2025-04-10 add schema pdf files
2025-04-10 pcb 3d
